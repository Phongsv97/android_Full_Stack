## rpi3_HAL-HIDL/Driver/hello/Kconfig
```kconfig
menu "Hello HAL menu"
config HELLO
	bool "hello"
	help 
		Select this option to build hello kernel module.			
endmenu 
```
